## examples/basic/sdkconfig.defaults
```kconfig
CONFIG_TINYUSB_HID_ENABLED=y
CONFIG_TINYUSB_HID_BUFSIZE=64
CONFIG_FREERTOS_HZ=1000
```
